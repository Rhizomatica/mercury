options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: A
  id: variable
  parameters:
    value: 1/math.sqrt(2)
  states: {}
- name: EsNo
  id: variable_qtgui_range
  parameters:
    label: Es/ No (dB)
    start: '-5'
    step: '0.1'
    stop: '100'
    value: '40'
  states: {}
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: gray
  id: variable
  parameters:
    value: '[A*(+1+1j), A*(-1+1j), A*(+1-1j), A*(-1-1j)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: Nc
  id: parameter
  parameters:
    type: intx
    value: '50'
  states: {}
- name: Ndata
  id: parameter
  parameters:
    type: intx
    value: '736'
  states: {}
- name: Nfft
  id: parameter
  parameters:
    type: intx
    value: '128'
  states: {}
- name: Ngi
  id: parameter
  parameters:
    type: eng_float
    value: (4.0/64)*0
  states: {}
- name: Nsymb
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1.0/math.sqrt(10**(float(EsNo)/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: int(1e7)
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*10
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*10
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*10
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*10
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/math.sqrt(50)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: int(math.log(M,2.0))
  states: {}
- name: blocks_rms_xx_0_1_0
  id: blocks_rms_xx
  parameters:
    alpha: '.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_1_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '.0001'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Ndata
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(Nfft*(1+Ngi))
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Nc
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: Nc*Nsymb
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nc
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(Nfft*(1+Ngi))
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: Nc*Nsymb
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Ndata
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: gray
  states: {}
- name: hermes_ofdm_deframer_0
  id: hermes_ofdm_deframer
  parameters:
    Dx: '6'
    Dy: '4'
    Nc: Nc
    Ndata: Ndata
    Nsymb: Nsymb
    edge_pilots: '1'
    pilot_mod: '0'
  states: {}
- name: hermes_ofdm_fft_0
  id: hermes_ofdm_fft
  parameters:
    direction: '1'
    size: Nfft
  states: {}
- name: hermes_ofdm_fft_1
  id: hermes_ofdm_fft
  parameters:
    direction: '0'
    size: Nfft
  states: {}
- name: hermes_ofdm_framer_0
  id: hermes_ofdm_framer
  parameters:
    Dx: '6'
    Dy: '4'
    Nc: Nc
    Ndata: Ndata
    Nsymb: Nsymb
    config_bits: '0'
    edge_pilots: '1'
    pilot_mod: '0'
  states: {}
- name: hermes_ofdm_gi_adder_0
  id: hermes_ofdm_gi_adder
  parameters:
    Nfft: Nfft
    Ngi: int(Nfft*Ngi)
  states: {}
- name: hermes_ofdm_gi_remover_0
  id: hermes_ofdm_gi_remover
  parameters:
    Nfft: Nfft
    Ngi: int(Nfft*Ngi)
  states: {}
- name: hermes_ofdm_zero_depadder_0
  id: hermes_ofdm_zero_depadder
  parameters:
    Nc: Nc
    Nfft: Nfft
  states: {}
- name: hermes_ofdm_zero_padder_0
  id: hermes_ofdm_zero_padder
  parameters:
    Nc: Nc
    Nfft: Nfft
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate*10
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate*10
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"rx"'
    size: '128'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"tx"'
    size: '128'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"tx"'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,1,1,1
    label1: SNR
    name: '"SNR"'
    type: float
    unit1: dB
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_rms_xx_0_1_0, '0']
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_rms_xx_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_freq_sink_x_1_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_rms_xx_0_1_0, '0', blocks_divide_xx_0, '1']
- [blocks_rms_xx_0_1_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_stream_to_vector_0, '0', hermes_ofdm_framer_0, '0']
- [blocks_stream_to_vector_0_0, '0', hermes_ofdm_gi_remover_0, '0']
- [blocks_stream_to_vector_0_1, '0', hermes_ofdm_zero_padder_0, '0']
- [blocks_stream_to_vector_0_2, '0', hermes_ofdm_deframer_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_1, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_throttle_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_throttle_1, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_1_0, '0', qtgui_const_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_vector_0, '0']
- [hermes_ofdm_deframer_0, '0', blocks_vector_to_stream_0_1_0, '0']
- [hermes_ofdm_fft_0, '0', hermes_ofdm_gi_adder_0, '0']
- [hermes_ofdm_fft_1, '0', hermes_ofdm_zero_depadder_0, '0']
- [hermes_ofdm_framer_0, '0', blocks_vector_to_stream_0_1, '0']
- [hermes_ofdm_gi_adder_0, '0', blocks_vector_to_stream_0_0, '0']
- [hermes_ofdm_gi_remover_0, '0', hermes_ofdm_fft_1, '0']
- [hermes_ofdm_zero_depadder_0, '0', blocks_vector_to_stream_0, '0']
- [hermes_ofdm_zero_padder_0, '0', hermes_ofdm_fft_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
