options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: EsN0
  id: variable_qtgui_range
  parameters:
    label: Es/ No (dB)
    start: '-20'
    step: '0.5'
    stop: '100'
    value: '30'
  states: {}
- name: Mercury_output_power
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: Rx_power_db
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,1
    name: '"rx power db"'
    type: float
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: 1.0/math.sqrt(10**(float(EsN0)/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"plughw:3,1,2"'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: '"plughw:3,1,4"'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"plughw:3,1,1"'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1
  id: audio_source
  parameters:
    device_name: '"plughw:3,1,3"'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.01'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.01'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: math.sqrt(Mercury_output_power)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_sink_x_2_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: tx_power_db
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,0
    name: '"tx power db"'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_multiply_const_xx_0_1, '0']
- [audio_source_0, '0', blocks_add_xx_1, '0']
- [audio_source_0, '0', blocks_rms_xx_0, '0']
- [audio_source_0_1, '0', blocks_add_xx_1_0, '1']
- [audio_source_0_1, '0', blocks_rms_xx_0_1, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_xx_0, '0']
- [blocks_add_xx_1_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_sink_x_2, '0']
- [blocks_multiply_const_xx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_sink_x_2_1, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_xx_0_1, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_rms_xx_0_0, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_rms_xx_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', tx_power_db, '0']
- [blocks_nlog10_ff_0_0, '0', Rx_power_db, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_rms_xx_0_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_rms_xx_0_1, '0', blocks_divide_xx_0_0, '0']

metadata:
  file_format: 1
